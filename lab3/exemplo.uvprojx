# Keil uVision project exemplo.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: exemplo
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: utils.s startup.s main.c gpio.c tm4c1294ncpdt.h assembly.h PWM.c PWM.h ServoMotor.c ServoMotor.h UART.c UART.h constants.h TerminalInteration.h TerminalInteration.c ADC.h ADC.c
    ../motor_control/: gpio.h
